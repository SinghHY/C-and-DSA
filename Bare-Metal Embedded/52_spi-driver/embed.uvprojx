# Keil uVision project embed.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: embed
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: main.cpp mcal_reg_access.h mcal_reg.h mcal_reg_access_dynamic.h uart.cpp uart.h systick.cpp systick.h tim2.cpp tim2.h adc.cpp adc.h i2c.cpp i2c.h spi.h spi.cpp
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
